# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, ARM_MATH_CM85, __FPU_PRESENT = 1, NDEBUG, RT_USING_LIBC, MICROPY_PY_DISPLAY = 1, CMSIS_NN, __CLK_TCK=RT_TICK_PER_SECOND, TF_LITE_STATIC_MEMORY, __RTTHREAD__, MICROPY_PY_SENSOR = 1
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\net\lwip\lwip-2.0.3\src\include;libraries\HAL_Drivers\config;packages\rw007-v2.1.0;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\libc\posix\io\eventfd;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy;board\ports\tf-micro\third_party\flatbuffers\include;packages\tinyusb\src;board\ports\CMSIS-NN\Include\Internal;rt-thread\components\net\sal\impl;board\ports\tf-micro\libtf;packages\micropython-v1.13.0\ports\renesas\boards\EK-RA8D1;packages\OpenMV-v4.5.0\src\hal;rt-thread\components\libc\compilers\common\include;packages\tinyusb\lib\rt-thread;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\special;board\ports\tf-micro;.;board\ports\omv_fs;rt-thread\components\net\netdev\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\sal\include;rt-thread\components\libc\posix\io\epoll;board\ports\tf-micro\third_party\ruy;rt-thread\libcpu\arm\common;packages\OpenMV-v4.5.0\src\omv\boards\RA8;packages\micropython-v1.13.0\lib\libm_dbl;rt-thread\components\drivers\spi;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\fft;board\ports;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\net\sal\include\socket;board\ports\tf-micro\signal\micro\kernels;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\signal;packages\OpenMV-v4.5.0\src\omv\imlib;packages\pahomqtt-latest\MQTTPacket\src;packages\micropython-v1.13.0\port\modules;rt-thread\components\libc\posix\ipc;board\ports\CMSIS-NN;rt-thread\components\net\sal\include\dfs_net;board\ports\mipi_lcd;packages\OpenMV-v4.5.0\src\omv\common;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\user;packages\OpenMV-v4.5.0\src\omv\modules;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\linalg;packages\micropython-v1.13.0\ports\renesas;board;packages\OpenMV-v4.5.0\src\omv\alloc;packages\OpenMV-v4.5.0\src\lib\libtf;packages\OpenMV-v4.5.0\src\omv;rt-thread\include;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\carray;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\micropython-v1.13.0\port;packages\OpenMV-v4.5.0\src\omv\ports\ra8;packages\micropython-v1.13.0\py;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\net\lwip\port;packages\OpenMV-v4.5.0\src\omv\sensors;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code;rt-thread\libcpu\arm\cortex-m85;board\ports\wifi;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\utils;board\ports\tf-micro\third_party\kissfft;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\ndarray;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\linalg;packages\OpenMV-v4.5.0\src\hal\cmsis\include;board\ports\tf-micro\signal\src;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\rw007-v2.1.0\inc;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\OpenMV-v4.5.0;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;packages\micropython-v1.13.0;rt-thread\components\drivers\wlan;rt-thread\components\finsh;libraries\HAL_Drivers;board\ports\CMSIS-NN\Include;board\ports\tf-micro\third_party\gemmlowp;board\ports\tf-micro\signal\src\kiss_fft_wrappers;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\optimize;packages\pahomqtt-latest\MQTTClient-RT;rt-thread\components\drivers\include;rt-thread\components\fal\inc;rt-thread\components\drivers\include;board\ports\scc8660;rt-thread\components\drivers\include;packages\micropython-v1.13.0\port\modules\machine;rt-thread\components\utilities\resource;rt-thread\components\libc\cplusplus;packages\micropython-v1.13.0\lib\utils;.\packages\pahomqtt-latest\samples
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group CMSIS_NN
    board/ports/CMSIS-NN/Source/ConvolutionFunctions/: arm_convolve_wrapper_s4.c arm_convolve_1x1_s8_fast.c arm_depthwise_conv_wrapper_s16.c arm_depthwise_conv_s4_opt.c arm_nn_depthwise_conv_s8_core.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_convolve_wrapper_s8.c arm_depthwise_conv_wrapper_s4.c arm_convolve_wrapper_s16.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_get_buffer_sizes_s4.c arm_depthwise_conv_3x3_s8.c arm_nn_mat_mult_kernel_s8_s16.c arm_convolve_get_buffer_sizes_s8.c arm_depthwise_conv_s4.c arm_convolve_1x1_s4.c arm_nn_mat_mult_kernel_s4_s16.c arm_convolve_1_x_n_s8.c arm_transpose_conv_get_buffer_sizes_s8.c arm_convolve_s4.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_convolve_get_buffer_sizes_s16.c arm_convolve_1x1_s8.c arm_depthwise_conv_wrapper_s8.c arm_convolve_fast_s16.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_depthwise_conv_s8_opt.c arm_convolve_1x1_s4_fast.c arm_depthwise_conv_fast_s16.c arm_nn_mat_mult_s8.c arm_depthwise_conv_s16.c arm_depthwise_conv_s8.c arm_transpose_conv_s8.c
    board/ports/CMSIS-NN/Source/FullyConnectedFunctions/: arm_fully_connected_get_buffer_sizes_s8.c arm_vector_sum_s8.c arm_fully_connected_s4.c arm_fully_connected_s8.c arm_fully_connected_s16.c arm_fully_connected_get_buffer_sizes_s16.c
    board/ports/CMSIS-NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_s16.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_s8.c
    board/ports/CMSIS-NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_mul_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16_s8.c arm_elementwise_mul_s8.c
    board/ports/CMSIS-NN/Source/NNSupportFunctions/: arm_nn_vec_mat_mult_t_s4.c arm_nn_lstm_update_cell_state_s16.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nn_lstm_calculate_gate_s8_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_vec_mat_mult_t_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_mat_mul_core_4x_s8.c arm_nn_lstm_update_output_s8_s16.c arm_nn_lstm_step_s8_s16.c arm_s8_to_s16_unordered_with_offset.c arm_nn_mat_mult_nt_t_s4.c arm_nn_mat_mul_kernel_s16.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_vec_mat_mul_result_acc_s8.c arm_nn_vec_mat_mult_t_s16.c arm_nn_mat_mult_nt_t_s8_s32.c arm_q7_to_q15_with_offset.c arm_nntables.c
    board/ports/CMSIS-NN/Source/PoolingFunctions/: arm_avgpool_get_buffer_sizes_s8.c arm_max_pool_s16.c arm_avgpool_get_buffer_sizes_s16.c arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s8.c
    board/ports/CMSIS-NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_y.c arm_concatenation_s8_x.c arm_concatenation_s8_z.c
    board/ports/CMSIS-NN/Source/LSTMFunctions/: arm_lstm_unidirectional_s8_s16.c
    board/ports/CMSIS-NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_get_buffer_sizes_s8.c arm_svdf_state_s16_s8.c
    board/ports/CMSIS-NN/Source/ActivationFunctions/: arm_relu_q15.c arm_relu_q7.c arm_relu6_s8.c arm_nn_activation_s16.c
    board/ports/CMSIS-NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_flash.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_sdhi.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_flash.c fal_rtt.c fal_partition.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group micropython
    packages/micropython-v1.13.0/py/: objzip.c objrange.c objenumerate.c vm.c emitnarm.c builtinhelp.c modsys.c objcomplex.c stackctrl.c pairheap.c vstr.c nlr.c objgetitemiter.c ringbuf.c objnamedtuple.c emitnative.c pystack.c emitnxtensawin.c asmthumb.c modthread.c objset.c omvdummy.c emitbc.c stream.c frozenmod.c objfilter.c objfloat.c parsenum.c nlraarch64.c objboundmeth.c profile.c modcmath.c emitnthumb.c modgc.c emitnx86.c objcell.c objexcept.c formatfloat.c parsenumbase.c nlrmips.c objint.c emitglue.c asmarm.c gc.c objfun.c smallint.c objtuple.c mpz.c objreversed.c emitcommon.c objmodule.c persistentcode.c runtime.c modio.c asmxtensa.c objobject.c objarray.c showbc.c nativeglue.c bc.c lexer.c asmx86.c nlrsetjmp.c objdeque.c objint_mpz.c objbool.c parse.c binary.c malloc.c nlrpowerpc.c nlrx86.c argcheck.c objlist.c objint_longlong.c objsingleton.c objtype.c asmbase.c map.c objnone.c nlrx64.c qstr.c asmx64.c modmath.c modbuiltins.c objstr.c builtinevex.c objstringio.c warning.c emitnx64.c builtinimport.c objmap.c scheduler.c moduerrno.c emitinlinethumb.c objslice.c runtime_utils.c compile.c objproperty.c obj.c unicode.c mpprint.c reader.c mpstate.c opmethods.c nlrxtensa.c objstrunicode.c repl.c modcollections.c objgenerator.c modarray.c emitinlinextensa.c objclosure.c scope.c modmicropython.c emitnxtensa.c modstruct.c sequence.c nlrthumb.c objpolyiter.c objdict.c objattrtuple.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/lib/utils/: printf.c stdout_helpers.c pyexec.c interrupt_char.c mpirq.c sys_stdio_mphal.c
    packages/micropython-v1.13.0/extmod/: modwebsocket.c modwebrepl.c modussl_mbedtls.c uos_dupterm.c moduwebsocket.c machine_signal.c virtpin.c modujson.c modurandom.c modubinascii.c modutimeq.c vfs_posix.c modure.c modbtree.c moduzlib.c machine_i2c.c modframebuf.c vfs_fat.c modonewire.c machine_pinbase.c moduselect.c vfs_reader.c machine_mem.c moducryptolib.c vfs_fat_file.c machine_spi.c vfs_fat_diskio.c moductypes.c utime_mphal.c moduhashlib.c vfs.c machine_pulse.c moduheapq.c vfs_posix_file.c modussl_axtls.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/drivers/bus/: softqspi.c softspi.c
  group micropython/machine
    packages/micropython-v1.13.0/port/modules/machine/: machine_adc.c machine_lcd.c machine_hw_i2c.c machine_timer.c modmachine.c machine_hw_spi.c machine_pin.c machine_wdt.c machine_pwm.c machine_uart.c machine_rtc.c
  group micropython/modules
    packages/micropython-v1.13.0/port/modules/: modusocket.c modnetwork.c moduos.c modnetwork_wlan.c modutils.c modutime.c modpyb.c modffi.c modrtthread.c modfile.c moduos_file.c
    packages/micropython-v1.13.0/port/: mpy_main.c mpputsnport.c mpgetcharport.c frozen_mpy.c mphalport.c gccollect.c mpthreadport.c
    packages/micropython-v1.13.0/port/native/: easyflash_module.c native_module.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
  group micropython/ra-port
    packages/micropython-v1.13.0/ports/renesas/: bufhelper.c pyb_uart.c led.c tinyusb_debug.c pyb_i2c.c machine_led.c
  group openmv/alloc
    packages/OpenMV-v4.5.0/src/omv/alloc/: umm_malloc.c xalloc.c fb_alloc.c unaligned_memcpy.c dma_alloc.c
  group openmv/common
    packages/OpenMV-v4.5.0/src/omv/common/: usbdbg.c trace.c sensor_utils.c array.c factoryreset.c mutex.c ringbuf.c vospi.c
  group openmv/dsp
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c arm_cos_q31.c arm_cos_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_sin_q15.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q31.c arm_rfft_init_q15.c
  group openmv/imlib
    packages/OpenMV-v4.5.0/src/omv/imlib/: hog.c selective_search.c font.c draw.c jpeg.c apriltag.c mathop.c binary.c rectangle.c template.c stereo.c point.c isp.c fsort.c lbp.c zbar.c qsort.c fft.c bayer.c edge.c blob.c stats.c filter.c png.c mjpeg.c haar.c fast.c lsd.c lab_tab.c qrcode.c hough.c bmp.c line.c rainbow_tab.c xyz_tab.c sincos_tab.c orb.c yuv.c framebuffer.c clahe.c ppm.c integral_mw.c eye.c imlib.c lodepng.c fmath.c jpegd.c agast.c integral.c gif.c collections.c pool.c kmeans.c dmtx.c phasecorrelation.c
  group openmv/modules
    packages/OpenMV-v4.5.0/src/omv/modules/: py_mjpeg.c py_spi_display.c py_clock.c py_imageio.c py_sensor.c py_omv.c py_display.c py_gif.c py_tf.c py_helper.c py_image.c
  group openmv/port/ra8
    packages/OpenMV-v4.5.0/src/omv/ports/ra8/: omv_gpio.c omv_lcd.c cambus.c sensor.c
  group openmv/rtt-port
    board/ports/omv_fs/: ff_wrapper.c
  group openmv/sensor
    packages/OpenMV-v4.5.0/src/omv/sensors/: gc2145.c lepton.c mt9m114.c scc8660.c ov2640.c ov7690.c frogeye2020.c hm01b0.c ov5640.c ov9650.c mt9v0xx.c hm0360.c ov7725.c paj6100.c gc0328.c ov7670.c
  group openmv/ulab
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/fft/: fft.c fft_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/carray/: carray_tools.c carray.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/: ndarray.c ulab_tools.c ulab.c ndarray_properties.c ndarray_operators.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/: transform.c vector.c compare.c filter.c stats.c approx.c numpy.c numerical.c create.c poly.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/user/: user.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/utils/: utils.c
  group openmv/ulab/scipy
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/: scipy.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/optimize/: optimize.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/linalg/: linalg.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/special/: special.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/signal/: signal.c
  group paho-mqtt
    packages/pahomqtt-latest/tests/: mqtt_test.c
    packages/pahomqtt-latest/samples/: mqtt_sample.c
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTSubscribeClient.c MQTTSerializePublish.c MQTTConnectServer.c MQTTFormat.c MQTTDeserializePublish.c MQTTConnectClient.c MQTTPacket.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c MQTTSubscribeServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group tensorflow
    board/ports/tf-micro/tensorflow/lite/micro/arena_allocator/: persistent_arena_buffer_allocator.cpp single_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp non_persistent_arena_buffer_allocator.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/: kernel_util.cpp
    board/ports/tf-micro/tensorflow/lite/schema/: schema_utils.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/internal/: quantization_util.cpp common.cpp tensor_utils.cpp tensor_ctypes.cpp portable_tensor_utils.cpp
    board/ports/tf-micro/tensorflow/lite/core/api/: flatbuffer_conversions.cpp error_reporter.cpp tensor_utils.cpp
    board/ports/tf-micro/tensorflow/lite/micro/memory_planner/: linear_memory_planner.cpp greedy_memory_planner.cpp
    board/ports/tf-micro/tensorflow/lite/core/c/: common.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/internal/reference/: comparisons.cpp portable_tensor_utils.cpp
  group tensorflow/cmsis_nn
    board/ports/tf-micro/tensorflow/lite/micro/kernels/cmsis_nn/: depthwise_conv.cpp fully_connected.cpp conv.cpp svdf.cpp add.cpp mul.cpp softmax.cpp pooling.cpp
  group tensorflow/kernels
    board/ports/tf-micro/tensorflow/lite/micro/kernels/: kernel_runner.cpp circular_buffer.cpp sub_common.cpp depthwise_conv_common.cpp broadcast_to.cpp log_softmax.cpp l2_pool_2d.cpp select.cpp strided_slice_common.cpp gather.cpp neg.cpp prelu_common.cpp l2norm.cpp logical.cpp squeeze.cpp hard_swish_common.cpp call_once.cpp pooling_common.cpp pad.cpp circular_buffer_common.cpp round.cpp reduce.cpp logistic.cpp comparisons.cpp var_handle.cpp batch_matmul.cpp ethosu.cpp softmax_common.cpp unidirectional_sequence_lstm.cpp space_to_batch_nd.cpp gather_nd.cpp logistic_common.cpp reshape.cpp split_v.cpp squared_difference.cpp ceil.cpp read_variable.cpp cumsum.cpp quantize.cpp tanh.cpp if.cpp reshape_common.cpp floor_mod.cpp floor_div.cpp exp.cpp unpack.cpp reduce_common.cpp micro_tensor_utils.cpp dequantize_common.cpp zeros_like.cpp activations_common.cpp activations.cpp hard_swish.cpp while.cpp leaky_relu_common.cpp pack.cpp fill.cpp div.cpp transpose_conv.cpp kernel_util.cpp add_n.cpp depth_to_space.cpp add_common.cpp mul_common.cpp elementwise.cpp prelu.cpp floor.cpp leaky_relu.cpp logical_common.cpp space_to_depth.cpp conv_common.cpp sub.cpp fully_connected_common.cpp batch_to_space_nd.cpp lstm_eval.cpp arg_min_max.cpp resize_nearest_neighbor.cpp shape.cpp svdf_common.cpp detection_postprocess.cpp quantize_common.cpp assign_variable.cpp cast.cpp elu.cpp split.cpp transpose.cpp maximum_minimum.cpp broadcast_args.cpp mirror_pad.cpp embedding_lookup.cpp resize_bilinear.cpp strided_slice.cpp dequantize.cpp expand_dims.cpp slice.cpp lstm_eval_common.cpp concatenation.cpp
    board/ports/tf-micro/tensorflow/lite/micro/cortex_m_generic/: micro_time.cpp debug_log.cpp
  group tensorflow/lib
    board/ports/tf-micro/libtf/: libtf.cpp libtf_builtin_models.c
  group tensorflow/micro
    board/ports/tf-micro/tensorflow/lite/micro/: micro_profiler.cpp mock_micro_graph.cpp micro_interpreter.cpp micro_resource_variable.cpp flatbuffer_utils.cpp memory_helpers.cpp micro_context.cpp test_helper_custom_ops.cpp micro_interpreter_graph.cpp micro_op_resolver.cpp micro_log.cpp micro_utils.cpp micro_allocation_info.cpp test_helpers.cpp fake_micro_context.cpp system_setup.cpp micro_interpreter_context.cpp micro_allocator.cpp recording_micro_allocator.cpp
    board/ports/tf-micro/tensorflow/lite/micro/tflite_bridge/: micro_error_reporter.cpp flatbuffer_conversions_bridge.cpp
  group tensorflow/signal
    board/ports/tf-micro/signal/src/: rfft_int16.cpp max_abs.cpp log.cpp filter_bank_square_root.cpp pcan_argc_fixed.cpp msb_32.cpp window.cpp rfft_int32.cpp msb_64.cpp energy.cpp irfft_float.cpp irfft_int32.cpp square_root_64.cpp filter_bank_spectral_subtraction.cpp fft_auto_scale.cpp rfft_float.cpp square_root_32.cpp overlap_add.cpp circular_buffer.cpp filter_bank_log.cpp irfft_int16.cpp filter_bank.cpp
    board/ports/tf-micro/signal/micro/kernels/: fft_auto_scale_kernel.cpp filter_bank_spectral_subtraction.cpp filter_bank_square_root.cpp irfft.cpp filter_bank_square_root_common.cpp pcan.cpp filter_bank.cpp delay.cpp fft_auto_scale_common.cpp framer.cpp energy.cpp filter_bank_log.cpp window.cpp overlap_add.cpp rfft.cpp stacker.cpp
    board/ports/tf-micro/signal/src/kiss_fft_wrappers/: kiss_fft_int32.cpp kiss_fft_int16.cpp kiss_fft_float.cpp
  group TinyUSB
    board/tinyusb/: drv_tinyusb.c usb_descriptors.c
    packages/tinyusb/src/class/cdc/: cdc_device.c
    packages/tinyusb/src/class/msc/: msc_device.c
    packages/tinyusb/src/common/: tusb_fifo.c
    packages/tinyusb/src/device/: usbd.c usbd_control.c
    packages/tinyusb/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c
    packages/tinyusb/src/: tusb.c
    packages/tinyusb/lib/rt-thread/port/: msc_device_port.c
    packages/tinyusb/lib/rt-thread/: tusb_rt_thread_port.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
  group WICED
    board/ports/scc8660/: scc8660.lib
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
